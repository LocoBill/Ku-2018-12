# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F330 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x1FFF) CLOCK(25000000)
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\test
  group Source Group 1
    ./: STARTUP.A51 main.c lmx2954.c
